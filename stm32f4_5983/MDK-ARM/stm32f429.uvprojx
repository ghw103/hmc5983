# Keil uVision project stm32f429.uvprojx, settings and files
target stm32f429 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F429ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: stm32f429
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,ARM_MATH_CM4,__TARGET_FPU_VFP,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__CC_ARM
  c misc: --C99
  c include: ../Inc;  ../Drivers/STM32F4xx_HAL_Driver/Inc;  ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Include;  ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;  ..\HARDWARE\LCD;  ..\HARDWARE\SRAM;  ..\HARDWARE\WiFi;  ..\uCOSiii\uC-CPU;  ..\uCOSiii\uC-LIB;  ..\uCOSiii\uCOS-III;  ..\uCOSiii\uCOS-bsp;  ..\uCOSiii\uCOS-config;  ..\uCOSiii\uCOS-III\Source;  ..\uCOSiii\uC-CPU\ARM-Cortex-M4\RealView;  ..\uCOSiii\uC-LIB\Ports\ARM-Cortex-M4\RealView;  ..\uCOSiii\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;  ..\uCOSiii\uCOS-bsp\OS\uCOS-III;  ..\HARDWARE\W25QXX;  ..\HARDWARE\24CXX;  ..\STemWin\Config;  ..\STemWin\inc;  ../Middlewares/Third_Party/FatFs/src/drivers;  ../Middlewares/Third_Party/FatFs/src;  ..\HARDWARE\HMC5983;  ..\HARDWARE\Log
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c sdio.c spi.c i2c.c rtc.c dma.c tim.c fmc.c usart.c adc.c gpio.c bsp_driver_sd.c fatfs.c WindowDLG.c
    ../uCOSiii/uCOS-config/: app_cfg.h
  group Hardware
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/WiFi/: WiFi.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/LCD/: R61408_LCD.c
    ../HARDWARE/HMC5983/: hmc5983.c
    ../HARDWARE/Log/: lcd_log.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_sram.c stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_sd.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_fmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_pwr.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_spi.c
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Stemwin
    ../STemWin/Config/: GUIConf.c LCDConf_FlexColor_Template.c
    ../STemWin/OS/: GUI_X.c
    ../STemWin/Lib/: STemWin528_CM4_Keil.lib
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: ff.c ff_gen_drv.c diskio.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
software components: CMSIS:CORE 4.3.0
